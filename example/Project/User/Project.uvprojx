# Keil uVision project Project.uvprojx, settings and files
target Aisx (ARM-ADS)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,__FPU_PRESENT=1,__FPU_USED =1
  c include: ..\FwLib\inc;..\StartupWare;..\Lua;..\User;..\Os\uC-Bsp;..\Os\uC-Config;..\Os\uC-Cpu;..\Os\uC-III;..\Os\uC-Lib;..\Os\uC-III\Source;..\Os\uC-Cpu\ARM-Cortex-M4\RealView;..\Os\uC-III\Ports\ARM-Cortex-M4\Generic\RealView;..\Os\uC-Lib\Ports\ARM-Cortex-M4\RealView
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group FwLib
    ../FwLib/src/: stm32f4xx_tim.c stm32f4xx_usart.c misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c
  group Lua
    ../Lua/: lapi.c lauxlib.c lbaselib.c lcode.c ldblib.c ldebug.c ldo.c ldump.c lfunc.c lgc.c linit.c liolib.c llex.c lmathlib.c lmem.c loadlib.c lobject.c lopcodes.c loslib.c lparser.c lstate.c lstring.c lstrlib.c ltable.c ltablib.c ltm.c lundump.c lvm.c lzio.c print.c
  group StartupWare
    ../StartupWare/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h startup_stm32f4xx.s
  group Os_Bsp
    ../Os/uC-Bsp/: bsp.c
  group Os_Cpu
    ../Os/uC-Cpu/: cpu_core.c
    ../Os/uC-Cpu/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
  group Os_Lib
    ../Os/uC-Lib/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../Os/uC-Lib/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group Os_Core
    ../Os/uC-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group Os_Port
    ../Os/uC-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group Os_Config
    ../Os/uC-Config/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
